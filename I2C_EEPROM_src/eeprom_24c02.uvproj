# Keil uVision project eeprom_24c02.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: eeprom_24c02 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 EEPROM_24C0x.c i2c.c main.c uart.c constants.h EEPROM_24C0x.h i2c.h io_conf.h main.h port.h uart.h
